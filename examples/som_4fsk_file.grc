options:
  parameters:
    author: Generated
    description: 4FSK file-based encode/decode with LDPC FEC
    generate_options: no_gui
    id: som_4fsk_file
    output_language: python
    run_options: run
    title: 4FSK File Encode/Decode
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: ldpc_matrix_file
  id: variable
  parameters:
    comment: Voice frame LDPC (rate 2/3) - for testing
    value: '"../ldpc_matrices/ldpc_voice_576_384.alist"'
  states: {}
- name: input_file
  id: variable
  parameters:
    comment: Input WAV file path
    value: '"input.wav"'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: Output WAV file path
    value: '"output.wav"'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: 4FSK modulator
    sensitivity: (2.0*math.pi*fsk_deviation)/rf_samp_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: 4FSK demodulator
    gain: rf_samp_rate/(2.0*math.pi*fsk_deviation)
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters:
    comment: Convert byte to short
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Save modulated signal to file
    file: output_file + '.mod'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Load modulated signal from file
    file: output_file + '.mod'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    comment: Pack bytes to 2-bit chunks for 4FSK
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_short_to_int_0
  id: blocks_short_to_int
  parameters:
    comment: Convert short to int
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters:
    comment: Convert hard bits to soft decisions (LLRs) for LDPC decoder
    scale: '2.0'
    vlen: '1'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    comment: Pack 2-bit chunks back to bytes
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    comment: Write decoded audio to WAV file
    bits_per_sample: '16'
    nchannels: '1'
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Read audio from WAV file
    file: input_file
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Map 2-bit chunks to 4FSK symbols
    dimension: '2'
    in_type: int
    out_type: float
    symbol_table: '[-3, -1, 1, 3]'
  states: {}
- name: digital_symbols_to_chunks_xx_0
  id: digital_symbols_to_chunks_xx
  parameters:
    comment: Map 4FSK symbols back to 2-bit chunks
    symbol_table: '[0, 1, 2, 3]'
    type: float
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Audio lowpass filter
    cutoff_freq: '3400'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: Audio lowpass filter
    cutoff_freq: '3400'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample to RF sample rate
    decim: '48'
    interp: '500'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: Resample from RF sample rate
    decim: '500'
    interp: '48'
    type: ccc
  states: {}
- name: ldpc_decoder_def
  id: variable_ldpc_decoder_def
  parameters:
    comment: LDPC decoder definition (rate 2/3)
    file: ldpc_matrix_file
    max_iter: '50'
    ndim: '0'
  states: {}
- name: ldpc_decoder_0
  id: fec_extended_decoder
  parameters:
    comment: LDPC decoder (rate 3/4)
    decoder_list: '[ldpc_decoder_def]'
    puncpat: '"11"'
    threadtype: ordinary
  states: {}
- name: vocoder_g711_decode_0
  id: vocoder_g711_decode
  parameters:
    decoding: vocoder.G711_ALAW
  states: {}
- name: ldpc_encoder_def
  id: variable_ldpc_encoder_def
  parameters:
    comment: LDPC encoder definition (rate 2/3)
    file: ldpc_matrix_file
    ndim: '0'
  states: {}
- name: ldpc_encoder_0
  id: fec_extended_encoder
  parameters:
    comment: LDPC encoder (rate 3/4)
    encoder_list: '[ldpc_encoder_def]'
    puncpat: '"11"'
    threadtype: ordinary
  states: {}
- name: vocoder_g711_encode_0
  id: vocoder_g711_encode
  parameters:
    encoding: vocoder.G711_ALAW
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbols_to_chunks_xx_0, '0']
- [blocks_char_to_short_0, '0', blocks_short_to_int_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_short_0, '0']
- [blocks_short_to_int_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_uchar_to_float_0, '0', ldpc_decoder_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_symbols_to_chunks_xx_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [ldpc_decoder_0, '0', vocoder_g711_decode_0, '0']
- [ldpc_encoder_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [low_pass_filter_0, '0', vocoder_g711_encode_0, '0']
- [low_pass_filter_1, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_1, '0', analog_quadrature_demod_cf_0, '0']
- [vocoder_g711_decode_0, '0', low_pass_filter_1, '0']
- [vocoder_g711_encode_0, '0', ldpc_encoder_0, '0']
- [rational_resampler_xxx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
