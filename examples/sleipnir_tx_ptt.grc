options:
  parameters:
    author: gr-sleipnir
    category: '[gr-sleipnir]'
    comment: TX example with GPIO PTT control
    description: gr-sleipnir transmitter with GPIO PTT control
    generate_options: no_gui
    id: sleipnir_tx_ptt
    output_language: python
    run_options: run
    title: gr-sleipnir TX with PTT
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    comment: Audio sample rate (8 kHz)
    value: '8000'
  states: {}
- name: callsign
  id: variable
  parameters:
    comment: Source callsign
    value: '"N0CALL"'
  states: {}
- name: gpio_pin
  id: variable
  parameters:
    comment: GPIO pin number for PTT control
    value: '18'
  states: {}
- name: input_file
  id: variable
  parameters:
    comment: Input WAV file path
    value: '"input.wav"'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: Output IQ file path
    value: '"tx_output.iq"'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    comment: RF sample rate (48 kHz)
    value: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Save modulated signal to IQ file
    file: output_file
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Read audio from WAV file
    file: input_file
    repeat: 'True'
  states: {}
- name: ptt_gpio_0
  id: python_block
  parameters:
    comment: GPIO PTT control block
    code: |-
      import sys
      from pathlib import Path
      sys.path.insert(0, str(Path(__file__).parent.parent))

      from python.ptt_gpio import make_ptt_gpio

      self.ptt = make_ptt_gpio(
          gpio_pin=int($gpio_pin),
          active_high=True
      )
    imports: ''
    state: 'True'
  states: {}
- name: sleipnir_tx_hier_0
  id: python_block
  parameters:
    comment: gr-sleipnir TX hierarchical block
    code: |-
      import sys
      from pathlib import Path
      sys.path.insert(0, str(Path(__file__).parent.parent))

      from python.sleipnir_tx_hier import sleipnir_tx_hier

      self.sleipnir_tx = sleipnir_tx_hier(
          callsign=$callsign,
          audio_samp_rate=$audio_samp_rate,
          rf_samp_rate=$rf_samp_rate,
          enable_signing=False,
          enable_encryption=False
      )
    imports: ''
    state: 'True'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', sleipnir_tx_hier_0, '0']
- [sleipnir_tx_hier_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
