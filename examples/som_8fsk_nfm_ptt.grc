options:
  parameters:
    author: Generated
    description: 8FSK NFM transceiver with PTT control
    generate_options: no_gui
    id: som_8fsk_nfm_ptt
    output_language: python
    run_options: run
    title: 8FSK NFM Transceiver with PTT
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '3600'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: ldpc_matrix_file
  id: variable
  parameters:
    comment: LDPC parity check matrix file (rate 2/3 for 8FSK) - update path as needed
    value: '"../ldpc_matrices/ldpc_rate23.alist"'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: 8FSK modulator
    sensitivity: (2.0*math.pi*fsk_deviation)/rf_samp_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: 8FSK demodulator
    gain: rf_samp_rate/(2.0*math.pi*fsk_deviation)
  states: {}
- name: audio_dev
  id: parameter
  parameters:
    label: Audio device
    short_id: a
    type: str
    value: hw:wm8960audio
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Speaker output
    device_name: audio_dev
    samp_rate: audio_samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Microphone input
    device_name: audio_dev
    maxoutbuf: '4800'
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: int
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters:
    comment: Convert float symbols to complex for frequency modulator
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: 2**31
  states: {}
- name: blocks_float_to_int_1
  id: blocks_float_to_int
  parameters:
    scale: 2**31
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: 2**31
  states: {}
- name: blocks_int_to_float_1
  id: blocks_int_to_float
  parameters:
    scale: 2**31
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: int
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '3'
    comment: Pack bytes to 3-bit chunks for 8FSK
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: int
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Throttle audio to prevent buffer issues
    samples_per_second: audio_samp_rate
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    comment: Throttle audio to prevent buffer issues
    samples_per_second: audio_samp_rate
    type: float
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters:
    comment: Convert byte to int for chunks_to_symbols
    scale: '1'
  states: {}
- name: blocks_short_to_int_0
  id: blocks_short_to_int
  parameters:
    comment: Convert short to int for chunks_to_symbols
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters:
    comment: Convert hard bits to soft decisions (LLRs) for LDPC decoder
    scale: '2.0'
    vlen: '1'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '3'
    comment: Pack 3-bit chunks back to bytes
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: int
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Map 3-bit chunks to 8FSK symbols
    dimension: '3'
    in_type: int
    out_type: float
    symbol_table: '[-7, -5, -3, -1, 1, 3, 5, 7]'
  states: {}
- name: digital_symbols_to_chunks_xx_0
  id: digital_symbols_to_chunks_xx
  parameters:
    comment: Map 8FSK symbols back to 3-bit chunks
    symbol_table: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: float
    vlen: '1'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading

      class ptt_gate(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="PTT Gate",
                  in_sig=[np.float32],
                  out_sig=[np.float32])
              self.message_port_register_in(pmt.intern("ptt"))
              self.set_msg_handler(pmt.intern("ptt"), self.handle_ptt_msg)
              self.ptt_state = False
              self.lock = threading.Lock()

          def handle_ptt_msg(self, msg):
              try:
                  if pmt.is_pair(msg):
                      msg_str = pmt.symbol_to_string(pmt.cdr(msg))
                  else:
                      msg_str = pmt.symbol_to_string(msg)
                  with self.lock:
                      if msg_str == "SOT":
                          self.ptt_state = True
                      elif msg_str == "EOT":
                          self.ptt_state = False
              except Exception as e:
                  print(f"PTT gate error: {e}")

          def work(self, input_items, output_items):
              with self.lock:
                  if self.ptt_state:
                      output_items[0][:] = input_items[0]
                  else:
                      output_items[0][:] = 0.0
              return len(output_items[0])
    comment: PTT gate - only pass audio when PTT is active
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Audio lowpass filter
    cutoff_freq: '3400'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: Audio lowpass filter
    cutoff_freq: '3400'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Resample to RF sample rate
    decim: '48'
    interp: '500'
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: Resample from RF sample rate
    decim: '500'
    interp: '48'
    type: ccc
  states: {}
- name: ldpc_decoder_def
  id: variable_ldpc_decoder_def
  parameters:
    comment: LDPC decoder definition (rate 2/3)
    file: ldpc_matrix_file
    max_iter: '50'
    ndim: '0'
  states: {}
- name: ldpc_decoder_0
  id: fec_extended_decoder
  parameters:
    comment: LDPC decoder (rate 2/3)
    decoder_list: '[ldpc_decoder_def]'
    puncpat: '"11"'
    threadtype: ordinary
  states: {}
- name: vocoder_g711_decode_0
  id: vocoder_g711_decode
  parameters:
    decoding: vocoder.G711_ALAW
  states: {}
- name: ldpc_encoder_def
  id: variable_ldpc_encoder_def
  parameters:
    comment: LDPC encoder definition (rate 2/3)
    file: ldpc_matrix_file
    ndim: '0'
  states: {}
- name: ldpc_encoder_0
  id: fec_extended_encoder
  parameters:
    comment: LDPC encoder (rate 2/3)
    encoder_list: '[ldpc_encoder_def]'
    puncpat: '"11"'
    threadtype: ordinary
  states: {}
- name: vocoder_g711_encode_0
  id: vocoder_g711_encode
  parameters:
    encoding: vocoder.G711_ALAW
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: ipc:///tmp/bsb_tx
    bind: 'False'
    comment: Baseband output to zmq_proxy
    timeout: '100'
    type: int
    vlen: '2048'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: ipc:///tmp/ptt_msg
    comment: PTT control messages
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: ipc:///tmp/bsb_rx
    comment: Baseband input from zmq_proxy
    timeout: '100'
    type: int
    vlen: '2048'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbols_to_chunks_xx_0, '0']
- [audio_source_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_int_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_int_1, '0']
- [blocks_deinterleave_0, '0', blocks_int_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_int_to_float_1, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_1, '0']
- [blocks_float_to_int_0, '0', blocks_interleave_0, '0']
- [blocks_float_to_int_1, '0', blocks_interleave_0, '1']
- [blocks_int_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_int_to_float_1, '0', blocks_float_to_complex_0, '1']
- [blocks_interleave_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_1, '0', audio_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', ldpc_decoder_0, '0']
- [ldpc_decoder_0, '0', vocoder_g711_decode_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_deinterleave_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_symbols_to_chunks_xx_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [epy_block_0, '0', vocoder_g711_encode_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']
- [low_pass_filter_1, '0', blocks_throttle_1, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_1, '0', analog_quadrature_demod_cf_0, '0']
- [vocoder_g711_decode_0, '0', low_pass_filter_1, '0']
- [vocoder_g711_encode_0, '0', ldpc_encoder_0, '0']
- [ldpc_encoder_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_short_0, '0']
- [blocks_char_to_short_0, '0', blocks_short_to_int_0, '0']
- [blocks_short_to_int_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [zeromq_sub_msg_source_0, out, epy_block_0, ptt]
- [zeromq_sub_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
