options:
  parameters:
    author: Generated
    description: 8FSK Digital Voice Receiver with Opus and LDPC FEC
    generate_options: no_gui
    id: rx_8fsk_opus
    output_language: python
    run_options: run
    title: 8FSK Opus RX
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: input_file
  id: variable
  parameters:
    comment: Input IQ file path
    value: '"rx_8fsk_input.iq"'
  states: {}
- name: ldpc_decoder_def
  id: variable_ldpc_decoder_def
  parameters:
    comment: LDPC decoder definition (rate 2/3)
    file: ldpc_matrix_file
    max_iter: '50'
    ndim: '0'
  states: {}
- name: ldpc_matrix_file
  id: variable
  parameters:
    comment: LDPC matrix for voice frames (rate 2/3)
    value: '"../ldpc_matrices/ldpc_rate23.alist"'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: Output WAV file path
    value: '"output.wav"'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: rrc_num_taps
  id: variable
  parameters:
    comment: Root Raised Cosine filter number of taps (11 symbols at RF rate)
    value: '110'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol
    value: rf_samp_rate / symbol_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    comment: AGC for power normalization
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: 8FSK quadrature demodulator
    gain: rf_samp_rate/(2.0*math.pi*fsk_deviation)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: Add 7 to map [-7,-5,-3,-1,1,3,5,7] -> [0,2,4,6,8,10,12,14]
    const: '7.0'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Load modulated signal from IQ file
    file: input_file
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    comment: Convert float to uchar for symbol mapping
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Multiply by 0.5 to map [0,2,4,6,8,10,12,14] -> [0,1,2,3,4,5,6,7]
    const: '0.5'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters:
    comment: Convert hard bits to soft decisions (LLRs) for LDPC decoder
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '3'
    comment: Pack 3-bit chunks back to bytes
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: Write decoded audio to WAV file
    file: output_file
    format: FORMAT_WAV
    samp_rate: audio_samp_rate
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Symbol timing recovery
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: gr_opus_opus_decoder_0
  id: gr_opus_opus_decoder
  parameters:
    channels: '1'
    comment: Opus decoder (8 kbps)
    packet_size: '0'
    sample_rate: audio_samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: ldpc_decoder_0
  id: fec_extended_decoder
  parameters:
    comment: 'LDPC decoder (rate 2/3: 12000 to 8000 bps)'
    decoder_list: '[ldpc_decoder_def]'
    puncpat: '"11"'
    threadtype: ordinary
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: Audio lowpass filter
    cutoff_freq: '3400'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    comment: Root Raised Cosine matched filter (RX)
    decim: '1'
    gain: '1'
    ntaps: rrc_num_taps
    samp_rate: rf_samp_rate
    sym_rate: symbol_rate
    type: fir_filter_fff
  states: {}

connections:
- [analog_agc2_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', analog_agc2_xx_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_uchar_to_float_0, '0', ldpc_decoder_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_add_const_vxx_0, '0']
- [gr_opus_opus_decoder_0, '0', low_pass_filter_1, '0']
- [ldpc_decoder_0, '0', gr_opus_opus_decoder_0, '0']
- [low_pass_filter_1, '0', blocks_wavfile_sink_0, '0']
- [root_raised_cosine_filter_1, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
