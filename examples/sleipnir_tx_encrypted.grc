options:
  parameters:
    author: gr-sleipnir
    category: '[gr-sleipnir]'
    comment: TX example with encryption and signing enabled
    description: gr-sleipnir transmitter with ECDSA signing and encryption enabled
    generate_options: no_gui
    id: sleipnir_tx_encrypted
    output_language: python
    run_options: run
    title: gr-sleipnir TX Encrypted
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    comment: Audio sample rate (8 kHz)
    value: '8000'
  states: {}
- name: callsign
  id: variable
  parameters:
    comment: Source callsign
    value: '"N0CALL"'
  states: {}
- name: input_file
  id: variable
  parameters:
    comment: Input WAV file path
    value: '"input.wav"'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: Output IQ file path
    value: '"tx_output_encrypted.iq"'
  states: {}
- name: private_key_path
  id: variable
  parameters:
    comment: Path to private key file (PEM format)
    value: '"keys/private.pem"'
  states: {}
- name: recipient
  id: variable
  parameters:
    comment: Recipient callsign(s), comma-separated
    value: '"N1ABC"'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    comment: RF sample rate (48 kHz)
    value: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Save modulated signal to IQ file
    file: output_file
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Read audio from WAV file
    file: input_file
    repeat: 'True'
  states: {}
- name: sleipnir_tx_hier_0
  id: python_block
  parameters:
    comment: gr-sleipnir TX with encryption and signing
    code: |-
      import sys
      from pathlib import Path
      sys.path.insert(0, str(Path(__file__).parent.parent))

      from python.sleipnir_tx_hier import sleipnir_tx_hier
      import os

      # Generate or load MAC key (32 bytes)
      mac_key = os.urandom(32)

      self.sleipnir_tx = sleipnir_tx_hier(
          callsign=$callsign,
          audio_samp_rate=$audio_samp_rate,
          rf_samp_rate=$rf_samp_rate,
          enable_signing=True,
          enable_encryption=True,
          private_key_path=$private_key_path,
          mac_key=mac_key
      )
    imports: ''
    state: 'True'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', sleipnir_tx_hier_0, '0']
- [sleipnir_tx_hier_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
