options:
  parameters:
    author: Generated
    description: 4FSK Digital Voice Transmitter with Opus and LDPC FEC
    generate_options: no_gui
    id: tx_4fsk_opus
    output_language: python
    run_options: run
    title: 4FSK Opus TX
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: input_file
  id: variable
  parameters:
    comment: Input WAV file path
    value: '"input.wav"'
  states: {}
- name: ldpc_encoder_def
  id: variable_ldpc_encoder_def
  parameters:
    comment: LDPC encoder definition (rate 3/4)
    file: /home/haaken/github-projects/gr-sleipnir/ldpc_matrices/ldpc_rate34.alist
    ndim: '0'
  states: {}
- name: ldpc_matrix_file
  id: variable
  parameters:
    comment: LDPC matrix for voice frames (rate 3/4)
    value: '"../ldpc_matrices/ldpc_rate34.alist"'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: Output IQ file path
    value: '"tx_output.iq"'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: rrc_num_taps
  id: variable
  parameters:
    comment: Root Raised Cosine filter number of taps (11 symbols at RF rate)
    value: '110'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: 4FSK frequency modulator
    sensitivity: (2.0*math.pi*fsk_deviation)/rf_samp_rate
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters:
    comment: Convert byte to short
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Save modulated signal to IQ file
    file: output_file
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Convert float symbols to complex for frequency modulator
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    comment: Convert float to int
    scale: '1'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    comment: Pack bytes to 2-bit chunks for 4FSK
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    comment: Convert short to float
    scale: '1'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Read audio from WAV file
    file: input_file
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Map 2-bit chunks to 4FSK symbols
    dimension: '1'
    in_type: int
    out_type: float
    symbol_table: '[-3, -1, 1, 3]'
  states: {}
- name: gr_opus_opus_encoder_0
  id: gr_opus_opus_encoder
  parameters:
    application: audio
    bitrate: '6000'
    channels: '1'
    comment: Opus encoder (6 kbps)
    sample_rate: audio_samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: ldpc_encoder_0
  id: fec_extended_encoder
  parameters:
    comment: 'LDPC encoder (rate 3/4: 384 to 512 bits)'
    encoder_list: '[ldpc_encoder_def]'
    puncpat: '"11"'
    threadtype: ordinary
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Audio lowpass filter
    cutoff_freq: '3400'
    decim: '1'
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    comment: Root Raised Cosine filter (TX pulse shaping)
    gain: '1'
    interp: '6'
    ntaps: rrc_num_taps
    samp_rate: rf_samp_rate
    sym_rate: symbol_rate
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_file_sink_0, '0']
- [blocks_char_to_short_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_complex_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_float_to_int_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_short_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_int_0, '0']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [gr_opus_opus_encoder_0, '0', ldpc_encoder_0, '0']
- [ldpc_encoder_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [low_pass_filter_0, '0', gr_opus_opus_encoder_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
