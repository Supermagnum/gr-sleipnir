options:
  parameters:
    author: gr-sleipnir
    category: '[gr-sleipnir]'
    comment: RX example with signature verification enabled
    description: gr-sleipnir receiver with signature verification and decryption
    generate_options: no_gui
    id: sleipnir_rx_verified
    output_language: python
    run_options: run
    title: gr-sleipnir RX Verified
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    comment: Audio sample rate (8 kHz)
    value: '8000'
  states: {}
- name: input_file
  id: variable
  parameters:
    comment: Input IQ file path
    value: '"rx_input.iq"'
  states: {}
- name: local_callsign
  id: variable
  parameters:
    comment: Local station callsign
    value: '"N0CALL"'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: Output WAV file path
    value: '"output.wav"'
  states: {}
- name: private_key_path
  id: variable
  parameters:
    comment: Path to private key for decryption
    value: '"keys/private.pem"'
  states: {}
- name: public_key_store
  id: variable
  parameters:
    comment: Path to public key store directory
    value: '"keys/public_keys"'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    comment: RF sample rate (48 kHz)
    value: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Save decoded audio to WAV file
    file: output_file
    nbits: '16'
    type: wav
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Read IQ samples from file
    file: input_file
    repeat: 'True'
    type: complex
  states: {}
- name: sleipnir_rx_hier_0
  id: python_block
  parameters:
    comment: gr-sleipnir RX with signature verification
    code: |-
      import sys
      from pathlib import Path
      sys.path.insert(0, str(Path(__file__).parent.parent))

      from python.sleipnir_rx_hier import sleipnir_rx_hier

      self.sleipnir_rx = sleipnir_rx_hier(
          local_callsign=$local_callsign,
          audio_samp_rate=$audio_samp_rate,
          rf_samp_rate=$rf_samp_rate,
          private_key_path=$private_key_path,
          require_signatures=False,  # Set to True to reject unsigned messages
          public_key_store_path=$public_key_store
      )
    imports: ''
    state: 'True'
  states: {}

connections:
- [blocks_file_source_0, '0', sleipnir_rx_hier_0, '0']
- [sleipnir_rx_hier_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
